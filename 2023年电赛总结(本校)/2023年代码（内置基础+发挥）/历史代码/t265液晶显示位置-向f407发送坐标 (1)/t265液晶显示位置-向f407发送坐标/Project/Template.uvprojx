# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Library\CMSIS\CM3\CoreSupport;..\Library\STM32F10x_StdPeriph_Driver\inc;..\Source;..\Source;..\Project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../Source/: stm32f10x_it.c stm32f10x_conf.h main.c config.c timer.c UART.c ttp229bsf.c uart_LCD.c delay.c key.c sys.c oled.c led.c
    ./: DataScope_DP.C
  group CMSIS
    ../Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group STM32_StdPeriph
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
