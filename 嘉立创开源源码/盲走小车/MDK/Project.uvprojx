# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\STM32F10xLib\inc;..\Source\STM32F10xLib\M3;..\Source\Drive;..\Source\wit_c_sdk;.\Moving
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../Source/APP/: Main.c
    ../Source/wit_c_sdk/: REG.h wit_c_sdk.c
  group DRIVER
    ../Source/Drive/: UART2.c UART1.c delay.c
  group FWLib
    ../Source/STM32F10xLib/M3/: system_stm32f10x.c stm32f10x_it.c
    ../Source/STM32F10xLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_pwr.c
    ../Source/STM32F10xLib/startup/: startup_stm32f10x_hd.s
  group Moving
    ./Moving/: Keyboard.h Keyboard.c bit_operation.h LX_DT.h moto.h LX_DT.c moto.c Oled.c Pid.c pwm.c Oled.h OLED_Font.h Pid.h pwm.h sys.h Timer.h sys.c Timer.c USART.c USART.h
    ../Source/STM32F10xLib/inc/: stm32f10x_tim.h
    ../Source/STM32F10xLib/src/: stm32f10x_tim.c
software components: CMSIS:CORE 4.3.0
