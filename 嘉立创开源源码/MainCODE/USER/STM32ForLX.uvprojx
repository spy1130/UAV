# Keil uVision project STM32ForLX.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: doubixiaohanhan +hex
  AfterMake: fromelf --bin --output C:\Users\PC\Desktop\STM32F103C8T6\program\STM32F103C8T6升级版\USER\obj\12345.bin  C:\Users\PC\Desktop\STM32F103C8T6\program\STM32F103C8T6升级版\USER\obj\doubixiaohanhan.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_StdPeriph_Driver\inc;..\APP\led;..\APP\button;..\BIT_Operation;..\delay;..\APP\timer;..\USART;..\APP\capture;..\APP\IAP;..\APP\CAN_LOOP;..\APP\LCD1602;..\APP\iwdg;..\APP\AT24C0X;..\APP\MPU60X0;..\APP\DHT11;..\APP\FLASH;..\APP\FLASH;..\USER;..\APP;..\STM32F1xx_HAL_Driver\Inc;..\STM32F1xx_HAL_Driver\Src;..\STM32F1xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c LX_DT.c LX_DT.h Timer.h Timer.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_gpio.c
  group CORE
    ../CORE/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c
  group startup
    ../CORE/: startup_stm32f10x_md.s
  group APP
    ../APP/: Oled.c Oled.h OLED_Font.h pwm.c pwm.h Keyboard.c Keyboard.h
  group BIT_Operation
    ../BIT_Operation/: bit_operation.h
  group DELAY
    ../delay/: delay.c
  group USART
    ../USART/: usart.c
